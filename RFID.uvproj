# Keil uVision project RFID.uvproj, settings and files
target 13.56MHz (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: RFID +hex
  c flags: Optimize=8 SizeSpeed=1
  group Main
    ./Src/: main.c
  group UART
    ./Src/: UART.c UART.h
  group PUBLIC
    ./Src/: PUBLIC.c PUBLIC.h
  group CLRC632
    ./Src/: CLRC632.c CLRC632.h
  group ISO14443A
    ./Src/: ISO14443A.c ISO14443A.h
  group ISO14443B
    ./Src/: ISO14443B.c ISO14443B.h
  group ISO15693
    ./Src/: ISO15693.c ISO15693.h
